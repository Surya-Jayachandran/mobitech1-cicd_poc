# Keil uVision project CICD_POC.uvproj, settings and files
target FreeRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M483SIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: CICD_POC +hex
  AfterMake: fromelf --bin ".\obj\CICD_POC.axf" --output ".\obj\CICD_POC.bin"
  AfterMake: fromelf --text -c ".\obj\CICD_POC.axf" --output ".\obj\CICD_POC.txt"
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: RVDS_ARMCM4_NUC4xx
  c include: C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\Library\CMSIS\Include;C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\Library\StdDriver\inc;C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\Library\Device\Nuvoton\M480\Include;C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\ThirdParty\FreeRTOS\Source\include;C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\ThirdParty\FreeRTOS\Demo\COMMON\include;C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;C:\Nuvoton\M480_BSP_CMSIS_V3.05.001\ThirdParty\FreeRTOS;..\..\DCON_AG_AIR;..\..\air_controller
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group System
    C:/Nuvoton/M480_BSP_CMSIS_V3.05.001/Library/Device/Nuvoton/M480/Source/: system_M480.c
    C:/Nuvoton/M480_BSP_CMSIS_V3.05.001/Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Demo Files
    ../: CICD_POC.c
  group lib
    C:/Nuvoton/M480_BSP_CMSIS_V3.05.001/Library/StdDriver/src/: retarget.c sys.c uart.c clk.c gpio.c timer.c spi.c i2c.c fmc.c eadc.c wdt.c
